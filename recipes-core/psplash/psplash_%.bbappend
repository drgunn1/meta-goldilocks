FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SPLASH_IMAGES:forcevariable = "file://future-logo.png;outsuffix=default"
