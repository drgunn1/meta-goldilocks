RDEPENDS:${PN} += " openthread-iwxxx-uart otbr-iwxxx-uart zigbee-rcp-sdk zigbee-rcp-apps "
