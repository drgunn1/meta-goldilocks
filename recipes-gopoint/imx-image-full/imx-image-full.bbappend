ROOTFS_POSTPROCESS_COMMAND:append: = "install_demo; "
