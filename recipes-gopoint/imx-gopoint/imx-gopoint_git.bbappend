FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
   	file://0001-modify-board-name-to-default-to-imx8mp-instead-of-im.patch \
   "


