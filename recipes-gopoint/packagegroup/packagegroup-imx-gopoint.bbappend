DEMOS:append = " imx-voice-example \
                        imx-voice-player \
                        imx-smart-kitchen \
                        imx-smart-fitness \
                        imx-nnstreamer-examples \
                        imx-ebike \
"

